# Keil uVision project CHIP_1.uvprojx, settings and files
target CHIP_1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: CHIP_1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_LOOPUNROLL,ARM_MATH_CM4,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED,__TARGET_FPU_VFP
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../OLED;../BUTTON;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../UC;../DSP/Include;../CONTROL;../SOGI;../PROTECT
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c tim.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group BUTTON
    ../BUTTON/: button.c button.h button_display.c button_display.h
  group OLED
    ../OLED/: customoled.c customoled.h oled.c oled.h oledfont.h sys.h
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group UC
    ../UC/: usercode.c usercode.h
  group DSP
    ../DSP/Source/BasicMathFunctions/: arm_abs_f32.c arm_abs_q7.c arm_abs_q15.c arm_abs_q31.c arm_add_f32.c arm_add_q7.c arm_add_q15.c arm_add_q31.c arm_dot_prod_f32.c arm_dot_prod_q7.c arm_dot_prod_q15.c arm_dot_prod_q31.c arm_mult_f32.c arm_mult_q7.c arm_mult_q15.c arm_mult_q31.c arm_negate_f32.c arm_negate_q7.c arm_negate_q15.c arm_negate_q31.c arm_offset_f32.c arm_offset_q7.c arm_offset_q15.c arm_offset_q31.c arm_scale_f32.c arm_scale_q7.c arm_scale_q15.c arm_scale_q31.c arm_shift_q7.c arm_shift_q15.c arm_shift_q31.c arm_sub_f32.c arm_sub_q7.c arm_sub_q15.c arm_sub_q31.c
    ../DSP/Source/CommonTables/: arm_common_tables.c arm_const_structs.c
    ../DSP/Source/ComplexMathFunctions/: arm_cmplx_conj_f32.c arm_cmplx_conj_q15.c arm_cmplx_conj_q31.c arm_cmplx_dot_prod_f32.c arm_cmplx_dot_prod_q15.c arm_cmplx_dot_prod_q31.c arm_cmplx_mag_f32.c arm_cmplx_mag_q15.c arm_cmplx_mag_q31.c arm_cmplx_mag_squared_f32.c arm_cmplx_mag_squared_q15.c arm_cmplx_mag_squared_q31.c arm_cmplx_mult_cmplx_f32.c arm_cmplx_mult_cmplx_q15.c arm_cmplx_mult_cmplx_q31.c arm_cmplx_mult_real_f32.c arm_cmplx_mult_real_q15.c arm_cmplx_mult_real_q31.c
    ../DSP/Source/ControllerFunctions/: arm_pid_init_f32.c arm_pid_init_q15.c arm_pid_init_q31.c arm_pid_reset_f32.c arm_pid_reset_q15.c arm_pid_reset_q31.c arm_sin_cos_f32.c arm_sin_cos_q31.c
    ../DSP/Source/FastMathFunctions/: arm_cos_f32.c arm_cos_q15.c arm_cos_q31.c arm_sin_f32.c arm_sin_q15.c arm_sin_q31.c arm_sqrt_q15.c arm_sqrt_q31.c
    ../DSP/Source/FilteringFunctions/: arm_biquad_cascade_df1_32x64_init_q31.c arm_biquad_cascade_df1_32x64_q31.c arm_biquad_cascade_df1_f32.c arm_biquad_cascade_df1_fast_q15.c arm_biquad_cascade_df1_fast_q31.c arm_biquad_cascade_df1_init_f32.c arm_biquad_cascade_df1_init_q15.c arm_biquad_cascade_df1_init_q31.c arm_biquad_cascade_df1_q15.c arm_biquad_cascade_df1_q31.c arm_biquad_cascade_df2T_f32.c arm_biquad_cascade_df2T_f64.c arm_biquad_cascade_df2T_init_f32.c arm_biquad_cascade_df2T_init_f64.c arm_biquad_cascade_stereo_df2T_f32.c arm_biquad_cascade_stereo_df2T_init_f32.c arm_conv_f32.c arm_conv_fast_opt_q15.c arm_conv_fast_q15.c arm_conv_fast_q31.c arm_conv_opt_q7.c arm_conv_opt_q15.c arm_conv_partial_f32.c arm_conv_partial_fast_opt_q15.c arm_conv_partial_fast_q15.c arm_conv_partial_fast_q31.c arm_conv_partial_opt_q7.c arm_conv_partial_opt_q15.c arm_conv_partial_q7.c arm_conv_partial_q15.c arm_conv_partial_q31.c arm_conv_q7.c arm_conv_q15.c arm_conv_q31.c arm_correlate_f32.c arm_correlate_fast_opt_q15.c arm_correlate_fast_q15.c arm_correlate_fast_q31.c arm_correlate_opt_q7.c arm_correlate_opt_q15.c arm_correlate_q7.c arm_correlate_q15.c arm_correlate_q31.c arm_fir_decimate_f32.c arm_fir_decimate_fast_q15.c arm_fir_decimate_fast_q31.c arm_fir_decimate_init_f32.c arm_fir_decimate_init_q15.c arm_fir_decimate_init_q31.c arm_fir_decimate_q15.c arm_fir_decimate_q31.c arm_fir_f32.c arm_fir_fast_q15.c arm_fir_fast_q31.c arm_fir_init_f32.c arm_fir_init_q7.c arm_fir_init_q15.c arm_fir_init_q31.c arm_fir_interpolate_f32.c arm_fir_interpolate_init_f32.c arm_fir_interpolate_init_q15.c arm_fir_interpolate_init_q31.c arm_fir_interpolate_q15.c arm_fir_interpolate_q31.c arm_fir_lattice_f32.c arm_fir_lattice_init_f32.c arm_fir_lattice_init_q15.c arm_fir_lattice_init_q31.c arm_fir_lattice_q15.c arm_fir_lattice_q31.c arm_fir_q7.c arm_fir_q15.c arm_fir_q31.c arm_fir_sparse_f32.c arm_fir_sparse_init_f32.c arm_fir_sparse_init_q7.c arm_fir_sparse_init_q15.c arm_fir_sparse_init_q31.c arm_fir_sparse_q7.c arm_fir_sparse_q15.c arm_fir_sparse_q31.c arm_iir_lattice_f32.c arm_iir_lattice_init_f32.c arm_iir_lattice_init_q15.c arm_iir_lattice_init_q31.c arm_iir_lattice_q15.c arm_iir_lattice_q31.c arm_lms_f32.c arm_lms_init_f32.c arm_lms_init_q15.c arm_lms_init_q31.c arm_lms_norm_f32.c arm_lms_norm_init_f32.c arm_lms_norm_init_q15.c arm_lms_norm_init_q31.c arm_lms_norm_q15.c arm_lms_norm_q31.c arm_lms_q15.c arm_lms_q31.c
    ../DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_add_q15.c arm_mat_add_q31.c arm_mat_cmplx_mult_f32.c arm_mat_cmplx_mult_q15.c arm_mat_cmplx_mult_q31.c arm_mat_init_f32.c arm_mat_init_q15.c arm_mat_init_q31.c arm_mat_inverse_f32.c arm_mat_inverse_f64.c arm_mat_mult_f32.c arm_mat_mult_fast_q15.c arm_mat_mult_fast_q31.c arm_mat_mult_q15.c arm_mat_mult_q31.c arm_mat_scale_f32.c arm_mat_scale_q15.c arm_mat_scale_q31.c arm_mat_sub_f32.c arm_mat_sub_q15.c arm_mat_sub_q31.c arm_mat_trans_f32.c arm_mat_trans_q15.c arm_mat_trans_q31.c
    ../DSP/Source/StatisticsFunctions/: arm_max_f32.c arm_max_q7.c arm_max_q15.c arm_max_q31.c arm_mean_f32.c arm_mean_q7.c arm_mean_q15.c arm_mean_q31.c arm_min_f32.c arm_min_q7.c arm_min_q15.c arm_min_q31.c arm_power_f32.c arm_power_q7.c arm_power_q15.c arm_power_q31.c arm_rms_f32.c arm_rms_q15.c arm_rms_q31.c arm_std_f32.c arm_std_q15.c arm_std_q31.c arm_var_f32.c arm_var_q15.c arm_var_q31.c
    ../DSP/Source/SupportFunctions/: arm_copy_f32.c arm_copy_q7.c arm_copy_q15.c arm_copy_q31.c arm_fill_f32.c arm_fill_q7.c arm_fill_q15.c arm_fill_q31.c arm_float_to_q7.c arm_float_to_q15.c arm_float_to_q31.c arm_q7_to_float.c arm_q7_to_q15.c arm_q7_to_q31.c arm_q15_to_float.c arm_q15_to_q7.c arm_q15_to_q31.c arm_q31_to_float.c arm_q31_to_q7.c arm_q31_to_q15.c
    ../DSP/Source/TransformFunctions/: arm_bitreversal.c arm_cfft_f32.c arm_cfft_q15.c arm_cfft_q31.c arm_cfft_radix2_f32.c arm_cfft_radix2_init_f32.c arm_cfft_radix2_init_q15.c arm_cfft_radix2_init_q31.c arm_cfft_radix2_q15.c arm_cfft_radix2_q31.c arm_cfft_radix4_f32.c arm_cfft_radix4_init_f32.c arm_cfft_radix4_init_q15.c arm_cfft_radix4_init_q31.c arm_cfft_radix4_q15.c arm_cfft_radix4_q31.c arm_cfft_radix8_f32.c arm_dct4_f32.c arm_dct4_init_f32.c arm_dct4_init_q15.c arm_dct4_init_q31.c arm_dct4_q15.c arm_dct4_q31.c arm_rfft_f32.c arm_rfft_fast_f32.c arm_rfft_fast_init_f32.c arm_rfft_init_f32.c arm_rfft_init_q15.c arm_rfft_init_q31.c arm_rfft_q15.c arm_rfft_q31.c
  group Lib
    ../DSP/Lib/: arm_cortexM4lf_math.lib
  group CONTROL
    ../CONTROL/: current_votage.c current_votage.h
  group SOGI
    ../SOGI/: sogi.c sogi.h
  group PROTECT
    ../PROTECT/: protect.c protect.h
software components: CMSIS:CORE 4.3.0
